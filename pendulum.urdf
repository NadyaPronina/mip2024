Commit message: homework

File: pendulum.urdf (robot description, URDF)
Before this commit: robot pendulum, 4 links, 3 joints
Links:
- link link_eef: mass 1 -> 2
